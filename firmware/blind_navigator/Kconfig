## firmware/blind_navigator/Kconfig
```kconfig
menu "configure app (blind_navigator) "

rsource "../ai_components/Kconfig"

endmenu
```
